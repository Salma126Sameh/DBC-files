<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LORA_STM.ewp</path>
  </project>
  <batchBuild />
</workspace>
